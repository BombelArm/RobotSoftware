Commit message: final

File: bombel/urdf/simple.urdf (robot description, URDF)
Before this commit: robot myrobot, 5 links, 4 joints
Links:
- link part4: geometry visual cylinder length=0.04 radius=0.015
